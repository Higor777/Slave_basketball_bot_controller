# Keil uVision project 第一个练习.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 第一个练习 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\FWlib\src;..\USER;..\USEFile;..\USEFile\BSP;..\USEFile\Communication;..\USEFile\DCMOTOR;..\USEFile\SteeringEngine;.\usart1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c delay.c stm32f10x_it.c
  group STARTCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c misc.c stm32f10x_adc.c
  group BSP
    ../USEFile/BSP/: BSP.c
  group DCMOTOR
    ../USEFile/DCMOTOR/: motorcontrol.c
  group Communication
    ../USEFile/Communication/: queue.c
    ./usart1/: bsp_usart1.c
